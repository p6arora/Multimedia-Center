# Keil uVision project project.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c system_LPC17xx.h LPC17xx.h
  group Configuration
    C:/Keil/ARM/CMSIS/uVision/LIB/ARM/: RTX_CM3.lib
  group Source
    ./: LED.h ADC.c ADC.h Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c IRQ.c LED.c KBD.c KBD.h
  group USB Audio
    ./: type.h adcuser.c adcuser.h audio.h core_cm3.c core_cm3.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbdmain.c usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h
  group Main Project
    ./: project.c
